# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,F407VG
  c misc: --diag_suppress=870
  c include: ..\Code\DCC;..\Code\ESP8266_AT;..\Code\Lyr0_Driver\ADC;..\Code\Lyr0_Driver\GPIO;..\Code\Lyr0_Driver\SDIO;..\Code\Lyr0_Driver\SPI;..\Code\Lyr0_Driver\SYSTICK;..\Code\Lyr0_Driver\USART;..\Code\Lyr0_Driver\CAN;..\Code\Lyr0_Driver\EXTI;..\Code\Lyr1_Protocol\Analog_Signal_Processing;..\Code\Lyr2_Device\SD;..\Code\Lyr2_Device\W25QXX;..\Code\Lyr2_Device\LCD;..\Code\Lyr3_Module\Files;..\Code\Lyr4_Socket\KEY;..\Code\Lyr4_Socket\LED;..\Code\Lyr4_Socket\LINE_IN;..\Code\Lyr4_Socket\Rocker;..\Code\Lyr5_Business\Data_Service;..\Code\Lyr5_Business\Menu;..\Code\Lyr5_Business\ESP32;..\Code\Lyr6_Application\GUI;..\Code\MALLOC;..\Code\System\API;..\Code\System\DELAY;..\Code\System
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group README
    ../: readme.txt
  group DDC
    ../Code/DCC/: sys.c startup_stm32f40_41xxx.s register.h
  group Lyr0_Driver
    ../Code/Lyr0_Driver/GPIO/: GPIO.c
    ../Code/Lyr0_Driver/SYSTICK/: Systick.c
    ../Code/Lyr0_Driver/USART/: USART.c
    ../Code/Lyr0_Driver/SPI/: spi.c
    ../Code/Lyr0_Driver/ADC/: ADC.c
    ../Code/Lyr0_Driver/CAN/: can.c
    ../Code/Lyr0_Driver/EXTI/: exti.c
  group Lyr1_Protocol
    ../Code/Lyr1_Protocol/Analog_Signal_Processing/: Analog_Signal_Processing.c
  group Lyr2_Deveice
    ../Code/Lyr2_Device/LCD/: ILI93xx.c
  group Lyr4_Socket
    ../Code/Lyr4_Socket/KEY/: KEY.c
    ../Code/Lyr4_Socket/LINE_IN/: Line_In.c
    ../Code/Lyr4_Socket/Rocker/: Rocker.c
    ../Code/Lyr4_Socket/LED/: LED.c
  group Lyr5_Business
    ../Code/Lyr5_Business/Data_Service/: Data_Service.c
    ../Code/Lyr5_Business/Menu/: Menu.c
    ../Code/Lyr5_Business/ESP32/: ESP32.c
  group SYSTEM
    ./: test.c
    ../Code/System/API/: API.c
    ../Code/System/DELAY/: Delay.c
    ../Code/System/: Toolkit.c
